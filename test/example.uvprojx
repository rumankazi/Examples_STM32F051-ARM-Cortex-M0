# Keil uVision project example.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: example
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\libraries;.\libraries\STM32F0xx_StdPeriph_Driver\inc;.\libraries\STM32F0xx_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../01_Blinky/libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/TrueSTUDIO/: startup_stm32f0xx.s
  group CMSIS
    ../01_Blinky/libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group src
    ../01_Blinky/src/: main.c
